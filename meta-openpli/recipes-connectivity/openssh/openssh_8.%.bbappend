inherit upx-compress

INSANE_SKIP_${PN} += "textrel"
