RDEPENDS_${PN}_remove += "mailx"


