CXXFLAGS_append_sh4 += " -fPIC -fno-strict-aliasing "
