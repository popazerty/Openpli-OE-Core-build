SRC_URI_sh4 = "git://github.com/oe-alliance/aio-grab.git;protocol=git"
